# IAR project pCO2Sensor.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430FR5994 MSP430FR5994
  General.GStackSize2: 1180
  General.GHeapSize2: 256
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: C:\version-control\EDD-pCO2Sensor\Firmware\pCO2Sensor\src
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  prebuild: CMD /C "pre-build2.bat"
  postbuild: post-build.bat $PROJ_DIR$
  XLINK.XclFile: lnk430fr5994.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: interrupts.c main.c
  group src
    src/: AM08x5.c AM08x5.h bsp.c bsp.h buffer16.c buffer16.h buffer8.c buffer8.h buffer_c.c buffer_c.h buffer_f.c buffer_f.h command.c command.h console.c console.h consoleCmd.c consoleCmd.h consoleIo.c consoleIo.h crc.c crc.h datalogger.c datalogger.h errorlist.h flowcontrol.c flowcontrol.h LED.c LED.h LI8x0.c LI8x0.h logging.c logging.h max250.c max250.h MAX310x.c MAX310x.h pco2.c pco2.h scheduler.c scheduler.h sht35.c sht35.h statistics.c statistics.h sysconfig.h sysinfo.c sysinfo.h version.h
  group src/driverlib
    src/driverlib/: adc12_b.c adc12_b.h aes256.c aes256.h comp_e.c comp_e.h crc.c crc.h crc32.c crc32.h cs.c cs.h dma.c dma.h driverlib.h esi.c esi.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h framctl_a.c framctl_a.h gpio.c gpio.h hspll.c hspll.h lcd_c.c lcd_c.h mpu.c mpu.h mpy32.c mpy32.h mtif.c mtif.h pmm.c pmm.h ram.c ram.h ref_a.c ref_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h saph.c saph.h sdhs.c sdhs.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h uups.c uups.h wdt_a.c wdt_a.h
  group src/driverlib/inc
    src/driverlib/inc/: hw_memmap.h version.h
